# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARM-COMPLIER-506)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\MDK-ARM;..\Core\Inc;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Middlewares\EasyLogger\inc;..\Tasks\Debug\inc;..\Middlewares\RTT;..\Tasks\BootManager\inc;..\Middlewares\Ymodem\inc;..\Middlewares\AES\inc;..\Bsp\W25Qxx\inc;..\Bsp\AT24Cxx_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User/Core
    ../Core/Src/: main.c tim.c gpio.c stm32f4xx_it.c usart.c flash.c spi.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Middlewares/Easylogger
    ../Middlewares/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Middlewares/EasyLogger/port/: elog_port.c
  group Middlewares/RTT
    ../Middlewares/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/Ymodem
    ../Middlewares/Ymodem/src/: common.c ymodem.c
  group Middlewares/AES
    ../Middlewares/AES/src/: AES.c
  group Bsp/W25qxx
    ../Bsp/W25Qxx/src/: w25qxx_Handler.c w25qxx.c
  group Bsp/AT24Cxx
    ../Bsp/AT24Cxx_Driver/src/: AT24Cxx_Driver.c iic.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Tasks/Debug
    ../Tasks/Debug/src/: Debug.c
  group Tasks/BootManager
    ../Tasks/BootManager/src/: Boot_Manager.c
